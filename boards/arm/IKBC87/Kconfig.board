## boards/arm/IKBC87/Kconfig.board
```kconfig
# Copyright (c) 2021 Nick Winans
# SPDX-License-Identifier: MIT

config BOARD_IKBC87
    bool "IKBC87"
    depends on SOC_NRF52840_QIAA
```
